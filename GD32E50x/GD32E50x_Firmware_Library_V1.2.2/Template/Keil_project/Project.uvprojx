# Keil uVision project Project.uvprojx, settings and files
target GD32E50X_CL (6120000::V6.12::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER
  c include: ..\;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32E50x\Include;..\..\Firmware\GD32E50x_standard_peripheral\Include;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../: main.c systick.c gd32e50x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group Peripherals
    ../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s startup_gd32e50x_hd.s startup_gd32e50x_xd.s startup_gd32eprt.s startup_gd32e508.s
  group Utilities
    ../../Utilities/: gd32e507z_eval.c
  group Doc
    ../: readme.txt
target GD32E50X_XD (6120000::V6.12::.\ARMCLANG)
  device: GD32E503ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_XD,USE_STDPERIPH_DRIVER
  c include: ..\..\Template;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32E50x\Include;..\..\Firmware\GD32E50x_standard_peripheral\Include;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32E50X_HD (6120000::V6.12::.\ARMCLANG)
  device: GD32E503ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: as above
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_HD,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32EPRT (6120000::V6.12::.\ARMCLANG)
  device: GD32EPRTVD GigaDevice
  pack: GigaDevice.GD32EPRT_DFP.1.0.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32EPRT,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32E508 (6120000::V6.12::.\ARMCLANG)
  device: GD32E508ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E508,USE_STDPERIPH_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.2.0
