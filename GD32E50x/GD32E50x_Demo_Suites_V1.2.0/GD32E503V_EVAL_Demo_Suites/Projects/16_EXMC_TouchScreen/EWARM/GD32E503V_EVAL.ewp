# IAR project GD32E503V_EVAL.ewp, settings and files
configuration GD32E50x (ARM, debug)
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_HD; GD32E50X
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\Utilities; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32E503Z_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e50x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_EVAL
    ../../../Utilities/: gd32e503v_eval.c gd32e503v_lcd_eval.c
  group GD32E50x_Peripherals
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_hd.s
