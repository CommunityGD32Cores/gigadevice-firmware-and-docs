# Keil uVision project GD32E503V_EVAL.uvprojx, settings and files
target GD32E503V_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32E503VE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32E50X GD32E50X_HD
  c include: ..\inc;..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\usbd\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\device\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\class\device\hid\Include;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Appliction
    ../src/: main.c gd32e50x_it.c gd32e50x_usbd_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_usart.c gd32e50x_timer.c gd32e50x_ctc.c
  group GD32E50x_EVAL
    ../../../Utilities/: gd32e503v_eval.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group USBD_Drivers
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
