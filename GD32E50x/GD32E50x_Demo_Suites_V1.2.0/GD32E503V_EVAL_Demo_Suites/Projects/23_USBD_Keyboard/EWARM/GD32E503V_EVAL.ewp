# IAR project GD32E503V_EVAL.ewp, settings and files
configuration GD32E50x (ARM, debug)
  General.OGChipSelectEditMenu: GD32E503xE GD GD32E503xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X_HD; GD32E50X
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\usbd\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\device\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbd_library\class\device\hid\Include; ..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: GD32E503V_EVAL.out
  group Application
    ../src/: gd32e50x_it.c gd32e50x_usbd_hw.c hid_keyboard_itf.c main.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_EVAL
    ../../../Utilities/: gd32e503v_eval.c
  group GD32E50x_Peripheral
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_hd.s
  group USBD_Class
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group USBD_Device
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Driver
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
