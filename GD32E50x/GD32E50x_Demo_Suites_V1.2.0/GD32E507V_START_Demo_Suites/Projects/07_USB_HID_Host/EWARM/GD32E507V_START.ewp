# IAR project GD32E507V_START.ewp, settings and files
configuration GD32E50X_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_FS; USE_FATFS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\core\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\class\hid\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32E507V_START.srec
  ILINK.IlinkOutputFile: GD32E507V_START.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E50X_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_HS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\class\hid\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\host\core\Include; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\hid; ..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common; ..\..\..\Utilities
  OBJCOPY.OOCOutputFile: usbh_hid.srec
  group Application
    ../src/: gd32e50x_it.c gd32e50x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_Peripherals
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_dma.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_spi.c gd32e50x_timer.c gd32e50x_usart.c
  group GD32E50x_START
    ../../../Utilities/: gd32e507v_start.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
  group USB_Class
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Driver
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
