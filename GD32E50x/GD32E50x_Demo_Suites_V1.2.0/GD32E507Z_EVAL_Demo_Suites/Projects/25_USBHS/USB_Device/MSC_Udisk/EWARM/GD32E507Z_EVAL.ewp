# IAR project GD32E507Z_EVAL.ewp, settings and files
configuration GD32E50X_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD; ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\class\msc\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\core\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\msc; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E50X_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_HS
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS; ..\..\..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\class\msc\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\device\core\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\class\msc; ..\..\..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_usbhs_library\ustd\common; ..\inc; ..\..\..\..\..\Utilities
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  group App
    ../src/: app.c gd32e50x_hw.c gd32e50x_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
  group GD32E50x_Peripherals
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_ctc.c gd32e50x_dma.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group Startup
    ../../../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
  group USB_Class
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../../GD32E50x_Firmware_Library/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
