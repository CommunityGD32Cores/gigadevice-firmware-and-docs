# Keil uVision project msc_cdrom.uvprojx, settings and files
target GD32E503 (6120000::V6.12::.\ARMCLANG)
  device: GD32E503ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.2.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER GD32E50X GD32E50X_HD
  c include: ..\inc;..\..\..\..\Firmware\CMSIS;..\..\..\..\Firmware\CMSIS\GD\GD32E50x\Include;..\..\..\..\Firmware\GD32E50x_standard_peripheral\Include;..\..\..\..\Firmware\GD32E50x_usbd_library\usbd\Include;..\..\..\..\Firmware\GD32E50x_usbd_library\device\Include;..\..\..\..\Firmware\GD32E50x_usbd_library\class\device\msc\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Appliction
    ../src/: main.c gd32e50x_it.c gd32e50x_usbd_hw.c msc_mem.c sram_data.c sram_msd.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_usart.c gd32e50x_fmc.c
  group GD32E50x_EVAL
    ../../../../Utilities/: gd32e503z_eval.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group USBD_Drivers
    ../../../../Firmware/GD32E50x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../Firmware/GD32E50x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../Firmware/GD32E50x_usbd_library/class/device/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
