# Keil uVision project printer.uvprojx, settings and files
target GD32E50X(USB_FS) (6120000::V6.12::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: printer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER,USE_USB_FS
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\Firmware\GD32E50x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\core\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\class\hid\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\class\printer\Include;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32e50x_hw.c gd32e50x_it.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_ctc.c
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32E50x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32E50x_usbhs_library/device/class/printer/Source/: printer_core.c
  group Doc
    ../: readme.txt
target GD32E50X(USB_HS) (6120000::V6.12::.\ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.0.0
  cpu: as above
  output: printer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32E50X,GD32E50X_CL,USE_STDPERIPH_DRIVER,USE_USB_HS
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32E50x\Include;..\..\..\..\..\Firmware\GD32E50x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\driver\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\core\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\class\printer\Include;..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.3.0
