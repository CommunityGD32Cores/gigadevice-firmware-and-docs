# Keil uVision project Project.uvproj, settings and files
target GD32307C_EVAL (ARM-ADS)
  device: GD32F307VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\class\cdc\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\core\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\class\cdc;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32f30x_it.c gd32f30x_hw.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group USB_Drivers
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Doc
    ../: readme.txt
