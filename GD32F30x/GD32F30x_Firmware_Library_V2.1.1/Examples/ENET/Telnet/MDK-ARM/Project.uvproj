# Keil uVision project Project.uvproj, settings and files
target GD32F30X_CL (ARM-ADS)
  device: GD32F307VG GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\inc;..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Source\ARM;..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\Firmware\CMSIS;..\lwip-1.4.1\src\include;..\lwip-1.4.1\src\include\ipv4;..\lwip-1.4.1\src\include\netif;..\lwip-1.4.1\src\include\lwip;..\lwip-1.4.1\port\GD32F30x;..\lwip-1.4.1\port\GD32F30x\Basic;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ../src/: main.c netconf.c hello_gigadevice.c gd32f30x_enet_eval.c gd32f30x_it.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Peripherals
    ../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exti.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_sdio.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c gd32f30x_bkp.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_exmc.c gd32f30x_i2c.c gd32f30x_rtc.c gd32f30x_spi.c gd32f30x_fmc.c
  group LwIP
    ../lwip-1.4.1/src/netif/: etharp.c
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.4.1/port/GD32F30x/Basic/: ethernetif.c
  group Utilities
    ../../../../Utilities/: gd32f307c_eval.c
  group doc
    ../src/: readme.txt
