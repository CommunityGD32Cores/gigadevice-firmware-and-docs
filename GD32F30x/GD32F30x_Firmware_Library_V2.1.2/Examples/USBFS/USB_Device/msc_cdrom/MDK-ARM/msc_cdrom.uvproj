# Keil uVision project msc_cdrom.uvproj, settings and files
target msc_cdrom (ARM-ADS)
  device: GD32F307VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F30X_CL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\device\class\msc\Include;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\class\msc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32f30x_it.c gd32f30x_hw.c flash_data.c flash_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_StdPeriph_Driver
    ../../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_ctc.c
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group USB_Drivers
    ../../../../../Firmware/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F30x_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Doc
    ../: readme.txt
