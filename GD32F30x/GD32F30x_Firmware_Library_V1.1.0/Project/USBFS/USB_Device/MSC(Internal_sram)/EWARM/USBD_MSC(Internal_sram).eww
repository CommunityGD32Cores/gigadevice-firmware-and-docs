<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_MSC(Internal_sram).ewp</path>
  </project>
  <batchBuild/>
</workspace>


