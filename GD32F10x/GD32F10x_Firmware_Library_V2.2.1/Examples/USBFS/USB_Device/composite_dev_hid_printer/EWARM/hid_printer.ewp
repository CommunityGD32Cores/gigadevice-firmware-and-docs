# IAR project hid_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\class\printer\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: hid_printer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_itf.c gd32f10x_hw.c gd32f10x_it.c hid_printer_wrapper.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c
  group GD32F10x_StdPeriph
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F10x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32F10x_usbfs_library/device/class/printer/Source/: printer_core.c
  group USB_Device
    ../../../../../Firmware/GD32F10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
