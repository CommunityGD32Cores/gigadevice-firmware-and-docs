# IAR project dfu.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_CL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\class\dfu\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio.srec
  ILINK.IlinkOutputFile: dfu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c flash_if.c gd32f10x_hw.c gd32f10x_it.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c
  group GD32F10x_StdPeriph
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F10x_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mal.c
  group USB_Device
    ../../../../../Firmware/GD32F10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
