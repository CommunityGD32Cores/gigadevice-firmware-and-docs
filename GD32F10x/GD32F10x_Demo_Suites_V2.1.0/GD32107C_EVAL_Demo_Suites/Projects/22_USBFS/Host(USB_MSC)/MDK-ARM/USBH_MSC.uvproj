# Keil uVision project USBH_MSC.uvproj, settings and files
target USBFS_MSC_HOST (ARM-ADS)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F10X_CL
  c include: ..\inc;..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_driver\Include;..\..\..\..\Utilities\LCD_common;..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c gd32f10x_it.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_StdPeriph_Driver
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f107c_eval.c gd32f107c_lcd_eval.c
    ../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group USB_Driver
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group Startup
    ../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: readme.txt
