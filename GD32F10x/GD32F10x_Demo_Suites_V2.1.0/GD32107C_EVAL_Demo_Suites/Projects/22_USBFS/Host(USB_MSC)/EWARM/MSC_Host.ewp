# IAR project MSC_Host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbfs_driver\Include; ..\..\..\..\Utilities\LCD_common; ..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f10x_it.c main.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f107c_eval.c gd32f107c_lcd_eval.c
    ../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
  group GD32F10x_Peripherals
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Driver
    ../../../../../GD32F10x_Firmware_Library/GD32F10x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
