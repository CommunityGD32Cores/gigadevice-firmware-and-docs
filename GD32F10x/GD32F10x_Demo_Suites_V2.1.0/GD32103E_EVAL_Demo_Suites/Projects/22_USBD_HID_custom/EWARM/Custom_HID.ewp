# IAR project Custom_HID.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xE GD GD32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include; ..\..\..\..\GD32F10x_Firmware_Library\GD32F10x_usbd_driver\Include; ..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Custom_HID.srec
  ILINK.IlinkOutputFile: Custom_HID.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: custom_hid_core.c gd32f10x_it.c main.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F103E_EVAL
    ../../../Utilities/: gd32f103e_eval.c
  group GD32F10x_StdPeriph
    ../../../../GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_hd.s
  group USBD_Drivers
    ../../../../GD32F10x_Firmware_Library/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
