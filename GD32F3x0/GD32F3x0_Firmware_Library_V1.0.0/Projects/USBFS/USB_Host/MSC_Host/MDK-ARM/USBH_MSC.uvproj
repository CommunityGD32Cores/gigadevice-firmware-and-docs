# Keil uVision project USBH_MSC.uvproj, settings and files
target USBFS_MSC_HOST (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: USBH-MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F350
  c include: ..\..\..\..\..\Firmware\CMSIS;..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_driver\Include;..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\..\Utilities\Third_Party\efsl\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: gd32f3x0_it.c main.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_usart.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c
  group GD32F3x0_EVAL
    ../../../../../Utilities/: gd32f3x0_eval.c
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group USB_Driver
    ../../../../../Firmware/GD32F3x0_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Doc
    ../: readme.txt
