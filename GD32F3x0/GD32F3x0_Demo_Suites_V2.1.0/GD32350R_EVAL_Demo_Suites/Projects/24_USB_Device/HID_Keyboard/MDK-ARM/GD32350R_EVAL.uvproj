# Keil uVision project GD32350R_EVAL.uvproj, settings and files
target GD32F350R_EVAL (ARM-ADS)
  device: GD32F350RB GigaDevice
  cpu: IRAM(0x20000000-0x20003FFF)IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F350
  c misc: --c99
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\driver\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\device\core\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\device\class\hid\Include;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\common;..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: app.c gd32f3x0_hw.c gd32f3x0_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group GD32F3x0_EVAL
    ../../../../Utilities/: gd32f350r_eval.c
  group USB_Drivers
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
