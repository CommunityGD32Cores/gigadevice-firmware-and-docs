# IAR project GD32350R_EVAL.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F350
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\driver\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\device\core\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\device\class\hid\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\common; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\class\hid; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_keyboard.srec
  ILINK.IlinkOutputFile: USB_Keyboard.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F350xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32f3x0_hw.c gd32f3x0_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group GD32F3x0_EVAL
    ../../../../Utilities/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Startup
    ../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group USB_Class
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
