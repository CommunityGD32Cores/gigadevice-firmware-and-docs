# IAR project GD32350R_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F350
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F3x0_Firmware_Library\CMSIS; ..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include; ..\..\..\Utilities; ..\ff9; ..\ff9\option; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32350R_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F350xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f3x0_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group ff9
    ../ff9/: diskio.c ff.c
  group GD32F3x0_EVAL
    ../../../Utilities/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: font.h gui.c gui.h lcd_driver.c lcd_driver.h spi_sd.c spi_sd.h
  group Startup
    ../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
