# IAR project GD32350R_EVAL.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F350
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\driver\Include; ..\..\..\..\Utilities; ..\..\..\..\Utilities\LCD_Common; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\host\core\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\host\class\hid\Include; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\common; ..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\class\hid
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Host.srec
  ILINK.IlinkOutputFile: USBH_HID.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F350xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f3x0_it.c gd32f3x0_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group GD32F350R_EVAL
    ../../../../Utilities/: gd32f350r_eval.c
    ../src/: gd32f3x0_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F3x0_Peripherals
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_exti.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Startup
    ../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group USB_Class
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Driver
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
