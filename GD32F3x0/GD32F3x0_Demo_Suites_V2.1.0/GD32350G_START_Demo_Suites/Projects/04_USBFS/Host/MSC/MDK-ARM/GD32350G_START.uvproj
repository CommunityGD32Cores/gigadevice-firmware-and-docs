# Keil uVision project GD32350G_START.uvproj, settings and files
target GD32F350G_START (ARM-ADS)
  device: GD32F350G8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF)IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH-MSC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F350
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\host\core\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\host\class\msc\Include;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_usbfs_library\ustd\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../src/: gd32f3x0_it.c gd32f3x0_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group GD32F3x0_START
    ../../../../../Utilities/: gd32f350g_start.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group USB_Driver
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32F3x0_Firmware_Library/GD32F3x0_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Startup
    ../../../../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
