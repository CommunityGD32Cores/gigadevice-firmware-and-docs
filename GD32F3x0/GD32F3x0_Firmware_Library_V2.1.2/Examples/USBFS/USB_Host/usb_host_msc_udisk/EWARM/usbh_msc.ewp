# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F350
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\class\msc; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f3x0_it.c gd32f3x0_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32F3x0_EVAL
    ../../../../../Utilities/: gd32f350r_eval.c
    ../src/: gd32f3x0_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F3x0_StdPeriph
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group USB_Class
    ../../../../../Firmware/GD32F3x0_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
