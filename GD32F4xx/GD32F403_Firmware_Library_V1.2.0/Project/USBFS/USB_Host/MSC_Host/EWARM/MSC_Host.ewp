# IAR project MSC_Host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F403
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F403_usbfs_driver\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
    ../src/: gd32f403_it.c main.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403Z_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c gd32f403z_lcd_eval.c
    ../../../../../Utilities/LCD_Commom/: lcd_log.c
  group GD32F403Z_Peripherals
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
  group USB_Driver
    ../../../../../Firmware/GD32F403_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
