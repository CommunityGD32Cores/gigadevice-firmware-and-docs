# Keil uVision project USBH_HID.uvproj, settings and files
target USBH_HID (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH-HID +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F403
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include;..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_driver\Include;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c usbh_usr.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usb_delay.c gd32f403_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group GD32F403Z_Peripherals
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group GD32F403Z_EVAL
    ../../../../../Utilities/LCD_Commom/: lcd_log.c
    ../../../../../Utilities/: gd32f403z_eval.c gd32f403z_lcd_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F403_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group Doc
    ../: readme.txt
