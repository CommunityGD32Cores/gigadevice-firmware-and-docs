# Keil uVision project MSC(Internal_sram).uvproj, settings and files
target MSC(Internal_sram) (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: USBFS_MSC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F403
  c misc: --c99
  c include: ..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include;..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_driver\Include;..\inc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_sram_access.c gd32f403_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group GD32F403_StdPeriph_Driver
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403Z_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group USB_Driver
    ../../../../../Firmware/GD32F403_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
