# IAR project HID_custom.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F403
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F403_usbfs_driver\Include; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_Keyboard.srec
  ILINK.IlinkOutputFile: HID_Custom.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F403xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_core.c gd32f403_it.c usb_delay.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403Z_eval.c
  group GD32F403_StdPeriph
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
  group USB_Drivers
    ../../../../../Firmware/GD32F403_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
