# Keil uVision project hid_host.uvproj, settings and files
target USBFS_usbh_hid (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F450
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\host\class\hid\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\host\core\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\hid;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: gd32f4xx_it.c gd32f4xx_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c
  group GD32F4xx_EVAL
    ../../../../Utilities/: gd32f450i_eval.c
    ../src/: gd32f450i_lcd_eval.c gd32f450i_eval_exmc_sdram.c lcd_font.c lcd_log.c
  group USB_Drivers
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Startup
    ../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
target USBHS_usbh_hid (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: as above
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: GD32F450,USE_USB_HS,USE_ULPI_PHY
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
