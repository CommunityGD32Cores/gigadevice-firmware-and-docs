# Keil uVision project msc_udisk.uvproj, settings and files
target USBFS_msc_udisk (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F450,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\class\msc\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\core\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\msc;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: app.c gd32f4xx_hw.c gd32f4xx_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph_Driver
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group USB_Drivers
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../GD32F4xx_Firmware_Library/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Startup
    ../../../../../GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
target USBHS_msc_udisk (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: as above
  output: msc_udisk +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F450,USE_USB_HS,USE_ULPI_PHY
  c misc: --c99
  c include: ..\inc;..\..\..\..\Utilities;..\..\..\..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_driver\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\class\msc\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\device\core\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\msc;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\class\msc;..\..\..\..\..\GD32F4xx_Firmware_Library\GD32F4xx_usb_library\ustd\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
