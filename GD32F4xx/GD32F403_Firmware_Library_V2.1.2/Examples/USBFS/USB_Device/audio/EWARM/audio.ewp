# IAR project audio.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F403; USE_USB_FS; USE_USB_AUDIO_SPEAKER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F403_usbfs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32F403_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F403_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: audio.srec
  ILINK.IlinkOutputFile: audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliaction
    ../src/: app.c gd32f403_audio_codec.c gd32f403_hw.c gd32f403_it.c
  group CMSIS
    ../src/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
  group GD32F403_StdPeriph
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: gd32f403_ctc.c gd32f403_dma.c gd32f403_exti.c gd32f403_fmc.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
  group USB_Class
    ../../../../../Firmware/GD32F403_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32F403_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
