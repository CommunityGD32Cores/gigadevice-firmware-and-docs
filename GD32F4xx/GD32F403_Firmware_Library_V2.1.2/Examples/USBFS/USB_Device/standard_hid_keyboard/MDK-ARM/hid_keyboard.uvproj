# Keil uVision project hid_keyboard.uvproj, settings and files
target hid_keyboard (ARM-ADS)
  device: GD32F403VK GigaDevice
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: hid_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F403
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include;..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\device\class\hid\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: app.c GD32F403_it.c GD32F403_hw.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_GD32F403.c
  group GD32F403_StdPeriph_Driver
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: GD32F403_exti.c GD32F403_gpio.c GD32F403_misc.c GD32F403_pmu.c GD32F403_rcu.c GD32F403_timer.c GD32F403_usart.c GD32F403_ctc.c
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
  group USB_Drivers
    ../../../../../Firmware/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F403_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F403_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_GD32F403.s
  group Doc
    ../: readme.txt
