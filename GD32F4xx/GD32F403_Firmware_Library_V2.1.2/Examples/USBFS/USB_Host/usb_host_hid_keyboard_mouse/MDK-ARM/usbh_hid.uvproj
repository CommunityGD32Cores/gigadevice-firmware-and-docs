# Keil uVision project usbh_hid.uvproj, settings and files
target usbh_hid (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F403
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include;..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\host\core\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\host\class\hid\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities\LCD_Commom;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c GD32F403_it.c GD32F403_usb_hw.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_GD32F403.c
  group GD32F403_Peripherals
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: GD32F403_exmc.c GD32F403_exti.c GD32F403_gpio.c GD32F403_misc.c GD32F403_pmu.c GD32F403_rcu.c GD32F403_timer.c GD32F403_usart.c
  group GD32F403_EVAL
    ../../../../../Utilities/LCD_Commom/: lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f403z_eval.c gd32f403z_lcd_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F403_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F403_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_GD32F403.s
  group Doc
    ../: readme.txt
