# Keil uVision project usbh_msc.uvproj, settings and files
target usbh_msc (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F403
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F403\Include;..\..\..\..\..\Firmware\GD32F403_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\host\core\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\host\class\msc\Include;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F403_usbfs_library\ustd\class\msc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_Commom;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c usbh_usr.c GD32F403_it.c GD32F403_usb_hw.c
  group CMSIS
    ../src/: system_GD32F403.c
  group GD32F403_StdPeriph_Driver
    ../../../../../Firmware/GD32F403_standard_peripheral/Source/: GD32F403_exmc.c GD32F403_exti.c GD32F403_gpio.c GD32F403_misc.c GD32F403_pmu.c GD32F403_rcu.c GD32F403_timer.c GD32F403_usart.c
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c gd32f403z_lcd_eval.c
    ../../../../../Utilities/LCD_Commom/: lcd_font.c lcd_log.c
  group USB_Driver
    ../../../../../Firmware/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F403_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F403_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F403/Source/ARM/: startup_GD32F403.s
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
