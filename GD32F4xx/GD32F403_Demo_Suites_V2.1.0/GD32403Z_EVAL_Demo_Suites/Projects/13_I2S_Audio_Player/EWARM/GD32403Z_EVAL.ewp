# IAR project GD32403Z_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: GD32F403
  ICCARM.CCIncludePath2: ..\Soft_Drive; ..\..\..\Utilities; ..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include; ..\..\..\..\GD32F403_Firmware_Library\CMSIS; ..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32403Z_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F403xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f403_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../Utilities/: gd32f403z_eval.c
  group GD32F403_Peripherals
    ../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: pcm1770.c spi_i2s.c
  group Startup
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
