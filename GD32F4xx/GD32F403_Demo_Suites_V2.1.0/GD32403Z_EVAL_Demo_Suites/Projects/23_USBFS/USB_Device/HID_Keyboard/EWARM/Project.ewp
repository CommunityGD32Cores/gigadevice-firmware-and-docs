# IAR project Project.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F403
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\device\class\hid\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\class\hid; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32f403_hw.c gd32f403_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
  group GD32F403_Peripherals
    ../../../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_ctc.c gd32f403_dma.c gd32f403_exti.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group Startup
    ../../../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
  group USB_Class
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
