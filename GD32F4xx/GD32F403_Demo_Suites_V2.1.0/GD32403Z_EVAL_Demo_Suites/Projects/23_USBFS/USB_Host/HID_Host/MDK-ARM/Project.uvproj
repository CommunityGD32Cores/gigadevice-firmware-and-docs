# Keil uVision project Project.uvproj, settings and files
target GD32403Z_EVAL (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F403
  c include: ..\..\..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\host\class\hid\Include;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\class\hid;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\host\core\Include;..\inc;..\LCD_Commom;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c GD32F403_it.c GD32F403_usb_hw.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_GD32F403.c
  group GD32F403_Peripherals
    ../../../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_ctc.c gd32f403_exmc.c gd32f403_exti.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
    ../LCD_Commom/: gd32f403z_lcd_eval.c lcd_font.c lcd_log.c
  group USB_Driver
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Startup
    ../../../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group Doc
    ../: readme.txt
