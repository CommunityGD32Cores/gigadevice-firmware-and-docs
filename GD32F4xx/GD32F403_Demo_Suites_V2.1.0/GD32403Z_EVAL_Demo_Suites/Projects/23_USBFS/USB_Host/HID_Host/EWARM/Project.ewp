# IAR project Project.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F403
  ICCARM.CCIncludePath2: ..\inc; ..\LCD_Commom; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\host\class\hid\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\host\core\Include; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\class\hid; ..\..\..\..\..\..\GD32F403_Firmware_Library\GD32F403_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f403_it.c gd32f403_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../../../Utilities/: gd32f403z_eval.c
    ../LCD_Commom/: gd32f403z_lcd_eval.c lcd_font.c lcd_log.c
  group GD32F403_Peripherals
    ../../../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_ctc.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_gpio.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_timer.c gd32f403_usart.c
  group Startup
    ../../../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
  group USB_Class
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Drivers
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F403_Firmware_Library/GD32F403_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
