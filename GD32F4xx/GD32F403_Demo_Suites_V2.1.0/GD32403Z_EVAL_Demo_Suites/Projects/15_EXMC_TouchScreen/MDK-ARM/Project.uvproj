# Keil uVision project Project.uvproj, settings and files
target GD32403Z_EVAL (ARM-ADS)
  device: GD32F403ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0807FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F403
  c include: ..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include;..\..\..\..\GD32F403_Firmware_Library\CMSIS;..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include;..\..\..\Utilities;..\;..\Soft_Drive;..\..\..\Utilities\LCD_Commom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../: main.c gd32f403_it.c systick.c
  group CMSIS
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group GD32F403_Peripherals
    ../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
  group GD32F403_EVAL
    ../../../Utilities/: gd32f403z_eval.c gd32f403z_lcd_eval.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
  group Startup
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/ARM/: startup_gd32f403.s
  group Doc
    ../: readme.txt
