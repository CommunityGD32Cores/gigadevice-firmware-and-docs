# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F403xE GD GD32F403xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_CL
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F403_Firmware_Library\GD32F403_standard_peripheral\Include; ..\..\..\..\GD32F403_Firmware_Library\CMSIS; ..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD\GD32F403\Include; ..\..\..\..\GD32F403_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; F:\svn\fwlib\GD_Board_Firmware_Routine\GD3223\GD32F403_Demo_Suites\GD32403Z_EVAL_Demo_Suites\Projects\14_EXMC_NandFlash\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F403xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: main.c
  group CMSIS
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/: system_gd32f403.c
  group Doc
    ../: readme.txt
  group GD32F403_EVAL
    ../../../Utilities/: gd32f403z_eval.c
  group GD32F403_Peripherals
    ../../../../GD32F403_Firmware_Library/GD32F403_standard_peripheral/Source/: gd32f403_adc.c gd32f403_bkp.c gd32f403_can.c gd32f403_crc.c gd32f403_ctc.c gd32f403_dac.c gd32f403_dbg.c gd32f403_dma.c gd32f403_exmc.c gd32f403_exti.c gd32f403_fmc.c gd32f403_fwdgt.c gd32f403_gpio.c gd32f403_i2c.c gd32f403_misc.c gd32f403_pmu.c gd32f403_rcu.c gd32f403_rtc.c gd32f403_sdio.c gd32f403_spi.c gd32f403_timer.c gd32f403_usart.c gd32f403_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: exmc_nandflash.c
  group Startup
    ../../../../GD32F403_Firmware_Library/CMSIS/GD/GD32F403/Source/IAR/: startup_gd32f403.s
