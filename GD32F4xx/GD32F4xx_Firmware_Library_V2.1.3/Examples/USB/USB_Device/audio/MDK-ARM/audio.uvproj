# Keil uVision project audio.uvproj, settings and files
target USBFS_audio (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: USBFS_Audio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F450,USE_USB_FS,USE_USB_AUDIO_MICPHONE,USE_USB_AUDIO_SPEAKER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\class\audio\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\core\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\common;..\..\..\..\..\Utilities
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: app.c gd32f4xx_hw.c gd32f4xx_it.c gd32f450i_audio_codec.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph_Driver
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_spi.c gd32f4xx_ctc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F4xx_usb_library/device/class/audio/Source/: audio_out_itf.c audio_core.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group Doc
    ../: readme.txt
target USBHS_audio (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: as above
  output: USBHS_audio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: GD32F450,USE_USB_HS,USE_ULPI_PHY,USE_USB_AUDIO_SPEAKER,USE_USB_AUDIO_MICPHONE
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
