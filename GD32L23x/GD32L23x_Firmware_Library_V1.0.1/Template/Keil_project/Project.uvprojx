# Keil uVision project Project.uvprojx, settings and files
target GD32L23x (6120000::V6.12::.\ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32L23x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32l23x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Peripherals
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_dac.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_usart.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_dbg.c gd32l23x_fwdgt.c gd32l23x_rtc.c gd32l23x_vref.c gd32l23x_adc.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_fmc.c gd32l23x_i2c.c gd32l23x_lpuart.c gd32l23x_pmu.c gd32l23x_spi.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_wwdgt.c gd32l23x_ctc.c gd32l23x_lptimer.c gd32l23x_slcd.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
  group Utilities
    ../../Utilities/: gd32l233r_eval.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
