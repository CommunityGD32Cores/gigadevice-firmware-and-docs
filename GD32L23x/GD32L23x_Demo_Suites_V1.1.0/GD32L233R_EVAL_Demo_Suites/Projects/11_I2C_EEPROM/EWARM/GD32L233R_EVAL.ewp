# IAR project GD32L233R_EVAL.ewp, settings and files
configuration GD32L23x (ARM, debug)
  General.OGChipSelectEditMenu: GD32L233xC GD GD32L233xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\Utilities; ..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include; ..\..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32L233R_EVAL.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32L233xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32l23x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Doc
    ../: readme.txt
  group GD32L23x_EVAL
    ../../../Utilities/: gd32l233r_eval.c
  group GD32L23x_Peripherals
    ../../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: at24cxx.c i2c.c
  group Startup
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/IAR/: startup_gd32l23x.s
