# IAR project GD32L233R_EVAL.ewp, settings and files
configuration GD32L23x (ARM, debug)
  General.OGChipSelectEditMenu: GD32L233xC GD GD32L233xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities; ..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include; ..\..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include; ..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\class\device\hid\Include; ..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\device\Include; ..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_usbd_library\usbd\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32L233R_EVAL.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32L233xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32l23x_it.c gd32l23x_usbd_hw.c hid_keyboard_itf.c main.c
  group CMSIS
    ../src/: system_gd32l23x.c
  group Doc
    ../: readme.txt
  group GD32L23x_EVAL
    ../../../Utilities/: gd32l233r_eval.c
  group GD32L23x_Peripherals
    ../../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_ctc.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_usart.c
  group Startup
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/IAR/: startup_gd32l23x.s
  group USBD_Class
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/class/device/hid/Source/: standard_hid_core.c
  group USBD_Device
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../GD32L23x_Firmware_Library/GD32L23x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
