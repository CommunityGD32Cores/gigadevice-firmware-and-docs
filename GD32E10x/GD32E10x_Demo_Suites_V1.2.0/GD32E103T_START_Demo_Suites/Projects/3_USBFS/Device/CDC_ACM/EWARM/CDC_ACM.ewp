# IAR project CDC_ACM.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32E10X; GD32E103T_START
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\class\cdc\Include; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\class\cdc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32E103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c
  group CMSIS
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E103T_START
    ../../../../../Utilities/: gd32e103t_start.c
  group GD32E10x_StdPeriph
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group Startup
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
  group USB_Class
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group USB_Device
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
