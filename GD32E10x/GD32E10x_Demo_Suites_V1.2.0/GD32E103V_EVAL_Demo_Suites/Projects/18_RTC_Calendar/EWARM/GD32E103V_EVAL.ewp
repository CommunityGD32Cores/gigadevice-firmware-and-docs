# IAR project GD32E103V_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E10X; GD32E103V_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include; ..\..\..\..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include; ..\..\..\Utilities; ..\..\..\Utilities\LCD_Commom; ..; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GD32E103V_EVAL.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32E103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e10x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E10x_EVAL
    ../../../Utilities/: gd32e103v_eval.c gd32e103v_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32E10x_Peripherals
    ../../../../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: rtc.c
  group Startup
    ../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
