# Keil uVision project cdc_acm.uvproj, settings and files
target cdc_acm (ARM-ADS)
  device: GD32E103RB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103R_START,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32E10x_Firmware_Library\CMSIS\GD\GD32E10x\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_standard_peripheral\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\core\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\device\class\cdc\Include;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32E10x_Firmware_Library\GD32E10x_usbfs_library\ustd\class\cdc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c
  group CMSIS
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_StdPeriph_Driver
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_standard_peripheral/Source/: gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group GD32E103R_START
    ../../../../../Utilities/: gd32e103r_start.c
  group Startup
    ../../../../../../GD32E10x_Firmware_Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group USB_Driver
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32E10x_Firmware_Library/GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Doc
    ../: readme.txt
