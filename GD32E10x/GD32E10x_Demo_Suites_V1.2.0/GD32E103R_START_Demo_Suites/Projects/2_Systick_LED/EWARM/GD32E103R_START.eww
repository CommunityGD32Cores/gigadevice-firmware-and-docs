<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GD32E103R_START.ewp</path>
  </project>
  <batchBuild/>
</workspace>


