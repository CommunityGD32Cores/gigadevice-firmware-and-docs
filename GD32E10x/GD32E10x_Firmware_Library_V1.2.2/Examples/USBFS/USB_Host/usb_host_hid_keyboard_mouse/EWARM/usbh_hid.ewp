# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32E10X; GD32E103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32e10x_it.c gd32e10x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E10x_EVAL
    ../src/: gd32e103v_lcd_eval.c
    ../../../../../Utilities/: gd32e10x_eval.c
    ../../usb_host_msc_udisk/src/: lcd_font.c lcd_log.c
  group GD32E10x_Peripherals
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
  group USB_Class
    ../../../../../Firmware/GD32E10x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Drivers
    ../../../../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32E10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
