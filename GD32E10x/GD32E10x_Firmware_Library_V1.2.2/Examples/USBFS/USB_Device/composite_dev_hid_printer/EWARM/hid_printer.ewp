# IAR project hid_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E103xB GD GD32E103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32E10X; GD32E103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include; ..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\class\printer\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: hid_printer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_itf.c gd32e10x_hw.c gd32e10x_it.c hid_printer_wrapper.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Doc
    ../: readme.txt
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e10x_eval.c
  group GD32E10x_StdPeriph
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_ctc.c gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/IAR/: startup_gd32e10x.s
  group USB_Class
    ../../../../../Firmware/GD32E10x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32E10x_usbfs_library/device/class/printer/Source/: printer_core.c
  group USB_Device
    ../../../../../Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
