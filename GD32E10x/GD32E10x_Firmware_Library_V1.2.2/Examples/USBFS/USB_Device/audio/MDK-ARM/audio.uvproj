# Keil uVision project audio.uvproj, settings and files
target audio (ARM-ADS)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: audio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_USB_FS,GD32E10X  GD32E103V_EVAL USE_USB_AUDIO_SPEAKER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\..\..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\..\..\..\..\Firmware\GD32E10x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32E10x_usbfs_library\device\class\audio\Include;..\..\..\..\..\Firmware\GD32E10x_usbfs_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_StdPeriph_Driver
    ../../../../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_ctc.c
  group GD32E10x_EVAL
    ../../../../../Utilities/: gd32e10x_eval.c
    ../src/: gd32e103v_audio_codec.c
  group USB_Drivers
    ../../../../../Firmware/GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32E10x_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
