# IAR project msc_cdrom.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32C103xB GD GD32C103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32C10X; GD32C103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32C10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\CMSIS\GD\GD32C10x\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\device\class\msc\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\class\msc; ..\..\..\..\..\Firmware\GD32C10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: msc_cdrom.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c flash_data.c flash_msd.c gd32c10x_hw.c gd32c10x_it.c usbd_storage_msd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Doc
    ../: readme.txt
  group GD32C10x_EVAL
    ../../../../../Utilities/: gd32c10x_eval.c
  group GD32C10x_StdPeriph
    ../../../../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_ctc.c gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32C10x/Source/IAR/: startup_gd32c10x.s
  group USB_Class
    ../../../../../Firmware/GD32C10x_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32C10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
