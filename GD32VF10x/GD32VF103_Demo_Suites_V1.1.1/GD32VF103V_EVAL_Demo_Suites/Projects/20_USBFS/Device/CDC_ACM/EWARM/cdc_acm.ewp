# IAR project cdc_acm.ewp, settings and files
configuration GD32VF103 (RISCV, debug)
  General.GDeviceSelect: GD32VF103VBT6 GigaDevice GD32VF103VBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 2
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103V_EVAL; USE_USB_FS
  ICCRISCV.CCIncludePath2: ..; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_standard_peripheral\Include; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_usbfs_library\device\class\cdc\Include; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_usbfs_library\ustd\class\cdc; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32VF103_Firmware_Library\RISCV\drivers; ..\..\..\..\..\..\GD32VF103_Firmware_Library\RISCV\env_IAR; ..\..\..\..\..\..\GD32VF103_Firmware_Library\RISCV\stubs; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_standard_peripheral
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: app.c gd32vf103_hw.c gd32vf103_it.c system_gd32vf103.c
  group Doc
    ../: readme.txt
  group GD32VF103_EVAL
    ../../../../../Utilities/: gd32vf103v_eval.c
  group GD32VF103_Peripherals/Source
    ../../../../../../GD32VF103_Firmware_Library/GD32VF103_standard_peripheral/Source/: gd32vf103_eclic.c gd32vf103_exti.c gd32vf103_gpio.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_timer.c gd32vf103_usart.c
  group RISCV/drivers
    ../../../../../../GD32VF103_Firmware_Library/RISCV/drivers/: n200_func.c
  group RISCV/env_IAR
    ../../../../../../GD32VF103_Firmware_Library/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../../../../../GD32VF103_Firmware_Library/RISCV/stubs/: write.c
  group USB_Class
    ../../../../../../GD32VF103_Firmware_Library/GD32VF103_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group USB_Device
    ../../../../../../GD32VF103_Firmware_Library/GD32VF103_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../../GD32VF103_Firmware_Library/GD32VF103_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
