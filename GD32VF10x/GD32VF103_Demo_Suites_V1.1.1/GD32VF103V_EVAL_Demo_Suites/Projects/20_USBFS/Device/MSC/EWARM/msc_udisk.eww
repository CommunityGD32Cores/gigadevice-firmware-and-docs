<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\msc_udisk.ewp</path>
    </project>
    <batchBuild />
</workspace>
