<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\usbh_hid.ewp</path>
    </project>
    <batchBuild />
</workspace>
