# IAR project GD32VF103V_EVAL.ewp, settings and files
configuration GD32VF103 (RISCV, debug)
  General.GDeviceSelect: GD32VF103VBT6 GigaDevice GD32VF103VBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCDefines: GD32VF103V_EVAL
  ICCRISCV.CCIncludePath2: ..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_standard_peripheral\Include; ..\..\..\..\GD32VF103_Firmware_Library\GD32VF103_standard_peripheral; ..\..\..\..\GD32VF103_Firmware_Library\RISCV\drivers; ..\..\..\Utilities; ..; ..\..\..\..\GD32VF103_Firmware_Library\RISCV\env_IAR; ..\Soft_Drive; ..\..\..\Utilities\LCD_common
  OBJCOPY.OOCOutputFile: GD32VF103V_EVAL.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: GD32VF103V_EVAL.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: main.c systick.c
  group Doc
    ../: readme.txt
  group GD32VF103_EVAL
    ../../../Utilities/: gd32vf103v_eval.c gd32vf103v_lcd_eval.c
    ../../../Utilities/LCD_common/: lcd_font.c
  group GD32VF103_Peripherals
    ../../../../GD32VF103_Firmware_Library/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group GD32VF103_Peripherals/Source
    ../../../../GD32VF103_Firmware_Library/GD32VF103_standard_peripheral/Source/: gd32vf103_adc.c gd32vf103_bkp.c gd32vf103_can.c gd32vf103_crc.c gd32vf103_dac.c gd32vf103_dbg.c gd32vf103_dma.c gd32vf103_eclic.c gd32vf103_exmc.c gd32vf103_exti.c gd32vf103_fmc.c gd32vf103_fwdgt.c gd32vf103_gpio.c gd32vf103_i2c.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_rtc.c gd32vf103_spi.c gd32vf103_timer.c gd32vf103_usart.c gd32vf103_wwdgt.c
  group RISCV/drivers
    ../../../../GD32VF103_Firmware_Library/RISCV/drivers/: n200_func.c
  group RISCV/env_IAR
    ../../../../GD32VF103_Firmware_Library/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../../../GD32VF103_Firmware_Library/RISCV/stubs/: write.c
  group Soft_Drive
    ../Soft_Drive/: picture.c touch_panel.c
