# IAR project Project.ewp, settings and files
configuration GD32VF103 (RISCV, debug)
  General.GDeviceSelect: GD32VF103VBT6 GigaDevice GD32VF103VBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103V_EVAL
  ICCRISCV.CCIncludePath2: ..\..\Firmware\GD32VF103_standard_peripheral\Include; ..\..\Firmware\GD32VF103_standard_peripheral; ..\..\Firmware\RISCV\drivers; ..\..\Utilities; ..; ..\..\Firmware\RISCV\env_IAR
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: main.c systick.c
  group Doc
    ../: readme.txt
  group GD32VF103_EVAL
    ../../Utilities/: gd32vf103v_eval.c
  group GD32VF103_Peripherals
    ../../Firmware/GD32VF103_standard_peripheral/: system_gd32vf103.c
  group GD32VF103_Peripherals/Source
    ../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_adc.c gd32vf103_bkp.c gd32vf103_can.c gd32vf103_crc.c gd32vf103_dac.c gd32vf103_dbg.c gd32vf103_dma.c gd32vf103_eclic.c gd32vf103_exmc.c gd32vf103_exti.c gd32vf103_fmc.c gd32vf103_fwdgt.c gd32vf103_gpio.c gd32vf103_i2c.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_rtc.c gd32vf103_spi.c gd32vf103_timer.c gd32vf103_usart.c gd32vf103_wwdgt.c
  group RISCV/drivers
    ../../Firmware/RISCV/drivers/: n200_func.c
  group RISCV/env_IAR
    ../../Firmware/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../Firmware/RISCV/stubs/: write.c
