<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hid_mouse.ewp</path>
    </project>
    <batchBuild />
</workspace>
