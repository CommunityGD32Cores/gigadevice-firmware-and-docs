# IAR project msc_cdrom.ewp, settings and files
configuration GD32VF103 (RISCV, debug)
  General.GDeviceSelect: GD32VF103VBT6 GigaDevice GD32VF103VBT6
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: GD32VF103V_EVAL; USE_USB_FS
  ICCRISCV.CCIncludePath2: ..\Include; ..\..\..\..\..\Firmware\GD32VF103_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32VF103_standard_peripheral; ..\..\..\..\..\Firmware\RISCV\drivers; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\RISCV\env_IAR; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\device\class\msc\Include; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\ustd\common; ..\..\..\..\..\Firmware\GD32VF103_usbfs_library\ustd\class\msc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Source/: app.c flash_data.c flash_msd.c gd32vf103_hw.c gd32vf103_it.c system_gd32vf103.c usbd_storage_msd.c
  group Doc
    ../: readme.txt
  group GD32VF103_EVAL
    ../../../../../Utilities/: gd32vf103v_eval.c
  group GD32VF103_Peripherals/Source
    ../../../../../Firmware/GD32VF103_standard_peripheral/Source/: gd32vf103_eclic.c gd32vf103_exti.c gd32vf103_gpio.c gd32vf103_pmu.c gd32vf103_rcu.c gd32vf103_timer.c gd32vf103_usart.c
  group RISCV/drivers
    ../../../../../Firmware/RISCV/drivers/: n200_func.c
  group RISCV/env_IAR
    ../../../../../Firmware/RISCV/env_IAR/: cstartup.s low_level_init.c
  group RISCV/stubs
    ../../../../../Firmware/RISCV/stubs/: write.c
  group USB_Class
    ../../../../../Firmware/GD32VF103_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32VF103_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32VF103_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
