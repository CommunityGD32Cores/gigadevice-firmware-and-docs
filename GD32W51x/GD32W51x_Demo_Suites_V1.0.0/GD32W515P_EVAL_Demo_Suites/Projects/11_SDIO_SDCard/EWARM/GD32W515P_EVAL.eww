<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32W515P_EVAL.ewp</path>
    </project>
</workspace>
