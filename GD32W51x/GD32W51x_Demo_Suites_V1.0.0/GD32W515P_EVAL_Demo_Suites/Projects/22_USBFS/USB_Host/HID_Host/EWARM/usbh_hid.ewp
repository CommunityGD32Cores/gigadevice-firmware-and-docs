# IAR project usbh_hid.ewp, settings and files
configuration GD32W51x (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; USE_FATFS; SYS_NS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32W51x_Firmware_Library\CMSIS\GD\GD32W51x\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_standard_peripheral\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\host\core\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_hid.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  group Application
    ../src/: gd32w51x_it.c gd32w51x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32w51x.c
  group Doc
    ../: readme.txt
  group GD32W515_EVAL
    ../../../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_standard_peripheral/Source/: gd32w51x_exti.c gd32w51x_gpio.c gd32w51x_misc.c gd32w51x_pmu.c gd32w51x_rcu.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_usart.c
  group Startup
    ../../../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
  group USB_Class
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Driver
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
