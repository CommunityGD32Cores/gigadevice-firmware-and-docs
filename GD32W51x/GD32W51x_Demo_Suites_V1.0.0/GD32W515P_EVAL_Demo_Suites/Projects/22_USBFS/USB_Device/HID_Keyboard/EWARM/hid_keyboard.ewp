# IAR project hid_keyboard.ewp, settings and files
configuration GD32W51x (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; SYS_NS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\GD32W51x_Firmware_Library\CMSIS\GD\GD32W51x\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_standard_peripheral\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\ustd\common; ..\..\..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hid_keyboard.srec
  ILINK.IlinkOutputFile: hid_keyboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c gd32w51x_hw.c gd32w51x_it.c hid_keyboard_itf.c
  group CMSIS
    ../src/: system_gd32w51x.c
  group Doc
    ../: readme.txt
  group GD32W51x_EVAL
    ../../../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_standard_peripheral/Source/: gd32w51x_exti.c gd32w51x_gpio.c gd32w51x_misc.c gd32w51x_pmu.c gd32w51x_rcu.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_usart.c
  group Startup
    ../../../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
  group USB_Class
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/device/class/hid/Source/: standard_hid_core.c
  group USB_Device
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../../GD32W51x_Firmware_Library/GD32W51x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
