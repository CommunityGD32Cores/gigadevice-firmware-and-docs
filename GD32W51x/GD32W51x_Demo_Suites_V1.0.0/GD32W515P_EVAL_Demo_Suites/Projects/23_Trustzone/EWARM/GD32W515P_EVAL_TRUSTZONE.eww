<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Secure_Project\GD32W515P_EVAL_SECURE.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Non_Secure_Project\GD32W515P_EVAL_NON_SECURE.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>GD32W515_TZ</name>
            <member>
                <project>Project_S</project>
                <configuration>GD32W51x</configuration>
            </member>
            <member>
                <project>Project_NS</project>
                <configuration>GD32W51x</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
