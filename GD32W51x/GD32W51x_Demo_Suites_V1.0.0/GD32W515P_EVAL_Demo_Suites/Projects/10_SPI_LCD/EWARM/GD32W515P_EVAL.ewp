# IAR project GD32W515P_EVAL.ewp, settings and files
configuration GD32W51x (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SYS_NS; GD32W515PI
  ICCARM.CCIncludePath2: ..; ..\..\..\Utilities; ..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_standard_peripheral\Include; ..\..\..\..\GD32W51x_Firmware_Library\CMSIS\GD\GD32W51x\Include; ..; ..\Soft_Drive; ..\Soft_Drive\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32W515P_EVAL.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32W515xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32w51x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
  group Doc
    ../: readme.txt
  group GD32W51x_EVAL
    ../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../../GD32W51x_Firmware_Library/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: gui.c lcd_driver.c
    ../Soft_Drive/IAR/: tft_test.c
  group Startup
    ../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
