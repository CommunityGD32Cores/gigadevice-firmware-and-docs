# Keil uVision project GD32W515P_EVAL.uvprojx, settings and files
target GD32W515P_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,SYS_NS
  c include: ..\..\..\..\GD32W51x_Firmware_Library\CMSIS;..\..\..\..\GD32W51x_Firmware_Library\CMSIS\GD\GD32W51x\Include;..\..\..\..\GD32W51x_Firmware_Library\GD32W51x_standard_peripheral\Include;..\..\..\Utilities;..\Soft_Drive;..\Soft_Drive\KEIL;..\..\10_SPI_LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
  group Application
    ../: main.c systick.c gd32w51x_it.c
  group CMSIS
    ../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
  group GD32W51x_Peripheral
    ../../../../GD32W51x_Firmware_Library/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_efuse.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group GD32W51x_EVAL
    ../../../Utilities/: gd32w515p_eval.c
  group Startup
    ../../../../GD32W51x_Firmware_Library/CMSIS/GD/GD32W51x/Source/ARM/: startup_gd32w51x.s
  group Doc
    ../: readme.txt
  group Soft_Drive
    ../Soft_Drive/: gui.c lcd_driver.c
    ../Soft_Drive/KEIL/: tft_test.c
software components: CMSIS:CORE 5.2.0
