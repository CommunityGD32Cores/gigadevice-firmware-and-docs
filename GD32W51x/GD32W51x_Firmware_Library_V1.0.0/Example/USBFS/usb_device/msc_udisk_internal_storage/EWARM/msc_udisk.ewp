# IAR project msc_udisk.ewp, settings and files
configuration GD32W515PI_S (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI_TZ GD GD32W515xI_TZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32W515PI
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\..\..\Firmware\GD32W51x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\class\msc\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\ustd\common; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\ustd\class\msc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: msc_udisk.srec
  ILINK.IlinkOutputFile: msc_udisk.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32W515xI_TZ.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32W515P0_S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515x0_TZ GD GD32W515x0_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32W515P0
configuration GD32W515Tx_S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515xG_TZ GD GD32W515xG_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32W515TX
configuration GD32W515PI_NS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; SYS_NS; GD32W515PI
  ILINK.IlinkIcfFile: D:\SVN\32101\GD32W51x_Firmware_Library\Example\USBFS\usb_device\msc_udisk_internal_storage\gd32w51x_flash_ns.icf
configuration GD32W515P0_NS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515x0_TZ GD GD32W515x0_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; SYS_NS; GD32W515P0
  ILINK.IlinkIcfFile: as above
configuration GD32W515Tx_NS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515xG_TZ GD GD32W515xG_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; SYS_NS; GD32W515TX
  ILINK.IlinkIcfFile: as above
  group App
    ../src/: app.c gd32w51x_hw.c gd32w51x_it.c sram_msd.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32w51x.c
  group Doc
    ../: readme.txt
  group GD32W515_EVAL
    ../../../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_exti.c gd32w51x_gpio.c gd32w51x_misc.c gd32w51x_pmu.c gd32w51x_rcu.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_tzpcu.c gd32w51x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
  group USB_Class
    ../../../../../Firmware/GD32W51x_usbfs_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_Device
    ../../../../../Firmware/GD32W51x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32W51x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
