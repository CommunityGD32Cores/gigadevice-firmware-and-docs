# Keil uVision project custom_hid.uvprojx, settings and files
target GD32W515PI_S (6120000::V6.12::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x70000) IRAM2(0x30000000,0x70000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32W515PI
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\..\..\Firmware\GD32W51x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32W51x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\class\hid\Include;..\..\..\..\..\Firmware\GD32W51x_usbfs_library\ustd\class\hid;..\..\..\..\..\Firmware\GD32W51x_usbfs_library\ustd\common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x70000
  group Application
    ../src/: app.c gd32w51x_hw.c gd32w51x_it.c custom_hid_itf.c
  group CMSIS
    ../src/: system_gd32w51x.c
  group GD32W51x_Peripherals
    ../../../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_exti.c gd32w51x_gpio.c gd32w51x_misc.c gd32w51x_rcu.c gd32w51x_timer.c gd32w51x_usart.c gd32w51x_syscfg.c gd32w51x_tzpcu.c
  group GD32W515_EVAL
    ../../../../../Utilities/: gd32w515p_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32W51x/Source/ARM/: startup_gd32w51x.s
  group USB_Driver
    ../../../../../Firmware/GD32W51x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32W51x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32W51x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
  group Doc
    ../: readme.txt
target GD32W515PI_NS (6120000::V6.12::.\ARMCLANG)
  device: GD32W515PIQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: as above
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,SYS_NS,GD32W515PI
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
target GD32W515P0_S (6120000::V6.12::.\ARMCLANG)
  device: GD32W515P0Q6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: as above
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32W515P0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x70000
target GD32W515P0_NS (6120000::V6.12::.\ARMCLANG)
  device: GD32W515P0Q6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: as above
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,SYS_NS,GD32W515P0
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x30000000 size 0x70000
target GD32W515TX_S (6120000::V6.12::.\ARMCLANG)
  device: GD32W515TGQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x60000) IRAM2(0x30000000,0x60000) IROM(0x08000000,0x0100000) IROM2(0x0C000000,0x0100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32W515TX
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x30000000 size 0x60000
target GD32W515TX_NS (6120000::V6.12::.\ARMCLANG)
  device: GD32W515TGQ6 GigaDevice
  pack: GigaDevice.GD32W51x_DFP.1.0.0
  cpu: as above
  output: custom_hid +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,SYS_NS,GD32W515TX
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x30000000 size 0x60000
software components: CMSIS:CORE 5.2.0
