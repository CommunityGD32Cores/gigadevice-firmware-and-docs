# IAR project usbd_audio.ewp, settings and files
configuration GD32W515PI (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; USE_USB_AUDIO_MICPHONE; USE_USB_AUDIO_SPEAKER; SYS_NS; GD32W515PI
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\..\..\Firmware\GD32W51x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32W51x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbd_audio.srec
  ILINK.IlinkOutputFile: usbd_audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32W515P0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515x0 GD GD32W515x0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; USE_USB_AUDIO_MICPHONE; USE_USB_AUDIO_SPEAKER; SYS_NS; GD32W515P0
configuration GD32W515Tx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515xG GD GD32W515xG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; USE_USB_AUDIO_MICPHONE; USE_USB_AUDIO_SPEAKER; SYS_NS; GD32W515TX
  group App
    ../src/: app.c audio_codec.c gd32w51x_hw.c gd32w51x_it.c
  group CMSIS
    ../src/: system_gd32w51x.c
  group Doc
    ../: readme.txt
  group GD32W515_EVAL
    ../../../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_dma.c gd32w51x_exti.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pmu.c gd32w51x_rcu.c gd32w51x_spi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
  group USB_Class
    ../../../../../Firmware/GD32W51x_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32W51x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32W51x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
