# IAR project Project_NS.ewp, settings and files
configuration GD32W515PI (ARM, debug)
  General.OGChipSelectEditMenu: GD32W515xI_TZ GD GD32W515xI_TZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32W515PI
  ICCARM.CCIncludePath2: ..\..\..\Firmware\CMSIS; ..\..\..\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\Firmware\GD32W51x_standard_peripheral\Include; ..; ..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_NS.srec
  ILINK.IlinkOutputFile: Project_NS.out
  ILINK.IlinkIcfFile: ..\gd32w51x_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ..\..\Secure\IAR_Project\NSC_LIB\secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32W515P0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515x0_TZ GD GD32W515x0_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32W515P0
configuration GD32W515Tx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32W515xG_TZ GD GD32W515xG_TZ
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32W515TX
  group Application
    ../: main.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
  group Doc
    ../../: readme.txt
  group GD32W51x_EVAL
    ../../../Utilities/: gd32w515p_eval.c
  group GD32W51x_Peripherals
    ../../../Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_adc.c gd32w51x_cau.c gd32w51x_cau_aes.c gd32w51x_cau_des.c gd32w51x_cau_tdes.c gd32w51x_crc.c gd32w51x_dbg.c gd32w51x_dci.c gd32w51x_dma.c gd32w51x_exti.c gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_hau.c gd32w51x_hau_sha_md5.c gd32w51x_hpdf.c gd32w51x_i2c.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_pkcau.c gd32w51x_pmu.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_rtc.c gd32w51x_sdio.c gd32w51x_spi.c gd32w51x_sqpi.c gd32w51x_syscfg.c gd32w51x_timer.c gd32w51x_trng.c gd32w51x_tsi.c gd32w51x_tzpcu.c gd32w51x_usart.c gd32w51x_wwdgt.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
