# IAR project Project_MBL_NS.ewp, settings and files
configuration GDM32 (ARM)
  General.OGChipSelectEditMenu: GD32W515xI GD GD32W515xI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: PLATFORM_GDM32
  ICCARM.CCDiagSuppress: Pa050,Pe223
  ICCARM.CCIncludePath2: ..\..\source_ns; ..\..\platform; ..\..\platform\gdm32; ..\..\..\config; ..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include; ..\..\..\ROM-EXPORT\platform; ..\..\..\ROM-EXPORT\source; ..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include; ..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc; ..\src\app
  OBJCOPY.OOCOutputFile: Project_MBL_NS.srec
  prebuild: mbl_prebuild.bat NTZ $PROJ_DIR$ "$TOOLKIT_DIR$"
  postbuild: ..\mbl_afterbuild_ns.bat SIP "" DAPLINK $TARGET_DIR$ $TARGET_BNAME$ IAR "$TOOLKIT_DIR$"
  ILINK.IlinkOutputFile: mbl-ns.axf
  ILINK.IlinkKeepSymbols: Reset_Handler
  ILINK.IlinkIcfFile: mbl_gdm32_ns.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bootloader
    ../../source_ns/: mbl_api.c mbl_flash.c mbl_image.c mbl_ns.c mbl_qspi_flash.c mbl_sys.c mbl_uart.c
  group gdm32
    ../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_misc.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_usart.c
    ../../../NSPE/Firmware/CMSIS/GD/GD32W51x/Source/IAR/: startup_gd32w51x.s
    ../../../NSPE/Firmware/CMSIS/GD/GD32W51x/Source/: system_gd32w51x.c
