# Keil uVision project Project_MBL_NS.uvprojx, settings and files
target Target_GDM32 (6090000::V6.9::.\ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: mbl-ns
  AfterMake: ..\mbl_afterbuild_ns.bat SIP "" JLINK $L @L KEIL $K
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GDM32
  c include: ..\..\source_ns;..\..\platform;..\..\platform\gdm32;..\..\..\config;..\..\..\ROM-EXPORT\mbedtls-2.17.0-rom\include;..\..\..\ROM-EXPORT\platform;..\..\..\ROM-EXPORT\source;..\..\..\NSPE\Firmware\CMSIS\GD\GD32W51x\Include;..\..\..\NSPE\Firmware\GD32W51x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ..\..\platform\gdm32\armclang\mbl_gdm32_ns.sct
  link misc: --predefine="-DPLATFORM_GDM32"  --keep=mbl_api
  group bootloader
    ../../source_ns/: mbl_flash.c mbl_image.c mbl_ns.c mbl_sys.c mbl_uart.c mbl_api.c mbl_qspi_flash.c
    ../../../ROM-EXPORT/symbol/: rom_symbol_mbedtls_20200709
  group gdm32
    ../../platform/gdm32/armclang/: mbl_startup_gdm32.s
    ../../platform/gdm32/cmsis_core/: mbl_system_gdm32.c
    ../../../NSPE/Firmware/GD32W51x_standard_peripheral/Source/: gd32w51x_fmc.c gd32w51x_fwdgt.c gd32w51x_gpio.c gd32w51x_icache.c gd32w51x_qspi.c gd32w51x_rcu.c gd32w51x_usart.c gd32w51x_misc.c
software components: CMSIS:CORE 5.1.1
