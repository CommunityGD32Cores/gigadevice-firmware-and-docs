# Keil uVision project Project.uvproj, settings and files
target GD32F20X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\inc;..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Source\ARM;..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\Firmware\CMSIS;..\..\..\..\Utilities;..\lwip-2.1.2\src\include;..\lwip-2.1.2\port\GD32F20x;..\lwip-2.1.2\port\GD32F20x\Basic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c gd32f20x_enet_eval.c gd32f20x_it.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Peripherals
    ../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group LwIP-Port
    ../lwip-2.1.2/port/GD32F20x/Basic/: ethernetif.c
  group LwIP
    ../lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.1.2/src/netif/: ethernet.c
  group Utilities
    ../../../../Utilities/: gd32f20x_eval.c
  group doc
    ../src/: readme.txt
