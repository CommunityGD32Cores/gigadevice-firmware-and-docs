# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxK GD GD32F20xxK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F20X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include; ..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f20x_it.c gd32f20x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Doc
    ../: readme.txt
  group GD32F20x_EVAL
    ../../usb_host_msc_udisk/src/: gd32f207i_lcd_eval.c gd32f207i_sdram_eval.c lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f20x_eval.c
  group GD32F20x_Peripherals
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_dma.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F20x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group USB_Drivers
    ../../../../../Firmware/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F20x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
