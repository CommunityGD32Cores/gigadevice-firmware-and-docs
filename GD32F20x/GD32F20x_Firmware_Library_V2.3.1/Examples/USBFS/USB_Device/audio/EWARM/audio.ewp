# IAR project audio.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxK GD GD32F20xxK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F20X_CL; USE_USB_FS; USE_USB_AUDIO_SPEAKER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include; ..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\class\audio\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio.srec
  ILINK.IlinkOutputFile: audio.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliaction
    ../src/: app.c gd32f207i_audio_codec.c gd32f20x_hw.c gd32f20x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Doc
    ../: readme.txt
  group GD32F20x_EVAL
    ../../../../../Utilities/: gd32f20x_eval.c
  group GD32F20x_StdPeriph
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_dma.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F20x_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group USB_Device
    ../../../../../Firmware/GD32F20x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
