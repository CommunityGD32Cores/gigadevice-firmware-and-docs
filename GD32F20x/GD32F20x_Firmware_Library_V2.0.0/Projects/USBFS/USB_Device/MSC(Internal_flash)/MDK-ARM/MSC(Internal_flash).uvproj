# Keil uVision project MSC(Internal_flash).uvproj, settings and files
target MSC(Internal_flash) (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MSC_flash +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F20X_CL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: gd32f20x_it.c usb_delay.c usbd_bbb_scsi.c usbd_flash_access.c usbd_msc_core.c app.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_StdPeriph_Driver
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_dma.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_usart.c
  group GD32F20x_EVAL
    ../../../../../Utilities/: gd32f207i_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32F20x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
