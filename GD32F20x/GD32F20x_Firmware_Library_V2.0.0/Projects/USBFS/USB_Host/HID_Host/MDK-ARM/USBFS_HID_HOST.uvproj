# Keil uVision project USBFS_HID_HOST.uvproj, settings and files
target USBFS_HID_HOST (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F20X_CL,USE_SYSTICK_DELAY
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_driver\Include;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: main.c gd32f20x_it.c usb_delay.c usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_usr.c systick.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_Peripherals
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_usart.c gd32f20x_tli.c
  group GD32F20x_EVAL
    ../../../../../Utilities/LCD_common/: lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f207i_eval.c gd32f207i_lcd_eval.c gd32f207i_sdram_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F20x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Doc
    ../: readme.txt
