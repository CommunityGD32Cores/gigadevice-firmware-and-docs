# Keil uVision project usbh_msc.uvproj, settings and files
target usbh_msc (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F20X_CL
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\host\core\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\host\class\msc\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\class\msc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: gd32f20x_it.c gd32f20x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_StdPeriph_Driver
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_usart.c gd32f20x_exmc.c
  group GD32F20x_EVAL
    ../src/: gd32f207i_lcd_eval.c gd32f207i_sdram_eval.c lcd_font.c lcd_log.c
    ../../../../../Utilities/: gd32f20x_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F20x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F20x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
