# Keil uVision project audio.uvproj, settings and files
target audio (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: audio +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F20X_CL USE_USB_AUDIO_SPEAKER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\Firmware\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\device\class\audio\Include;..\..\..\..\..\Firmware\GD32F20x_usbfs_library\ustd\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: app.c gd32f20x_hw.c gd32f20x_it.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_StdPeriph_Driver
    ../../../../../Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_dma.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_usart.c
  group GD32F20x_EVAL
    ../src/: gd32f207i_audio_codec.c
    ../../../../../Utilities/: gd32f20x_eval.c
  group USB_Drivers
    ../../../../../Firmware/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F20x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F20x_usbfs_library/device/class/audio/Source/: audio_core.c audio_out_itf.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Doc
    ../: readme.txt
