# IAR project GD32207C_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxC GD GD32F20xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F20X_CL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Utilities; ..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include; ..\..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include; ..\..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32207C_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F20xxC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Soft_Drive/: background.c picture.c
    ../: gd32f20x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Doc
    ../: readme.txt
  group GD32F207C_EVAL
    ../../../Utilities/: gd32f207c_eval.c
    ../Soft_Drive/: gd32f207c_lcd_eval.c
  group GD32F20x_Peripherals
    ../../../../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group Startup
    ../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/IAR/: startup_gd32f20x_cl.s
