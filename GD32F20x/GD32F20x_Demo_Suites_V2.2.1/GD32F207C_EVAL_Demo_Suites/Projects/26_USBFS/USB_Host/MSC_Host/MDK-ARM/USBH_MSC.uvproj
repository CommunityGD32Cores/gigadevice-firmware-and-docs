# Keil uVision project USBH_MSC.uvproj, settings and files
target usbh_msc (ARM-ADS)
  device: GD32F207VC GigaDevice
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-MSC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F20X_CL
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\host\core\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\host\class\msc\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\ustd\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: gd32f20x_it.c main.c usbh_usr.c gd32f20x_usb_hw.c
  group CMSIS
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_StdPeriph_Driver
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_usart.c
  group GD32F207C_EVAL
    ../../../../../Utilities/: gd32f207c_eval.c
  group Startup
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group USB_Driver
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
