# Keil uVision project usbh_hid.uvproj, settings and files
target usbh_hid (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBH-HID +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F20X_CL
  c include: ..\inc;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\host\core\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\host\class\hid\Include;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_usbfs_library\ustd\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: main.c usbh_usr.c usbh_usr_lcd.c gd32f20x_it.c gd32f20x_usb_hw.c gd32f207i_lcd_eval.c gd32f207i_sdram_eval.c lcd_font.c lcd_log.c
  group CMSIS
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_Peripherals
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_timer.c gd32f20x_usart.c gd32f20x_exmc.c gd32f20x_tli.c
  group GD32F207I_EVAL
    ../../../../../Utilities/: gd32f207i_eval.c
  group USB_Driver
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Startup
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Doc
    ../: readme.txt
