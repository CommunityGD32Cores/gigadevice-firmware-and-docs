# Keil uVision project GD32207I_EVAL.uvproj, settings and files
target GD32207I_EVAL (ARM-ADS)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GD32207I_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\..\..\..\..\..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\..\..\..\..\Utilities;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS;..\..\..\..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;..\inc;..\..\..\Third_party\lwip-2.0.2\src\include;..\..\..\Third_party\lwip-2.0.2\port\GD32F20x;..\..\..\Third_party\lwip-2.0.2\port\GD32F20x\FreeRTOS;..\..\..\Third_party\FreeRTOS-8.2.3\include;..\..\..\Third_party\FreeRTOS-8.2.3\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../src/: main.c netconf.c hello_gigadevice.c tcp_client.c udp_echo.c gd32f20x_enet_eval.c gd32f20x_it.c
  group CMSIS
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_Peripherals
    ../../../../../../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group GD32F207I_EVAL
    ../../../../../Utilities/: gd32f207i_eval.c
  group Lwip
    ../../../Third_party/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../Third_party/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../Third_party/lwip-2.0.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../Third_party/lwip-2.0.2/port/GD32F20x/FreeRTOS/: sys_arch.c ethernetif.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-8.2.3/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/RVDS/ARM_CM3/: port.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/MemMang/: heap_2.c
  group Startup
    ../../../../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Doc
    ../: readme.txt
