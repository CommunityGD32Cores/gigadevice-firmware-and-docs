# IAR project ScatterLoading.ewp, settings and files
configuration GD32F130_150 (ARM)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..; ..\..\..\Utilities; ..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\Firmware\GD32F1x0_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\gd32f1x0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F170_190 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F170_190
  group Application
    ../: const-data.c hw_config.c main.c
  group CMSIS
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_EVAL
    ../../../Utilities/: gd32f1x0_eval.c
  group GD32F1x0_Peripherals
    ../../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group Startup
    ../../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
