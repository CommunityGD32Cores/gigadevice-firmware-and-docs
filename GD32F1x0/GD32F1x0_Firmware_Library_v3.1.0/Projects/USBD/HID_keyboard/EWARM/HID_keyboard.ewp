# IAR project HID_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\Firmware\GD32F1x0_standard_peripheral\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_driver\Include; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Mouse.srec
  ILINK.IlinkOutputFile: HID_Keyboard.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F150x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f1x0_it.c hid_core.c main.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F150R_EVAL
    ../../../../Utilities/: gd32f1x0_eval.c
  group GD32F1x0_Peripherals
    ../../../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USB_Drivers
    ../../../../Firmware/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
