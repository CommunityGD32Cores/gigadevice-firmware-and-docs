# IAR project ccid.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\..\..\..\Utilities; ..\inc; ..\..\..\..\Firmware\CMSIS; ..\..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\Firmware\GD32F1x0_standard_peripheral\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\device\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\usbd\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\class\device\ccid\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: ccid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: gd32f1x0_it.c gd32f1x0_usbd_hw.c main.c smartcard.c smartcard_itf.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F1x0_EVAL
    ../../../../Utilities/: gd32f1x0r_eval.c
  group GD32F1x0_Peripherals
    ../../../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USBD_Class
    ../../../../Firmware/GD32F1x0_usbd_library/class/device/ccid/Source/: ccid_cmd.c ccid_core.c ccid_itf.c
  group USBD_Device
    ../../../../Firmware/GD32F1x0_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../Firmware/GD32F1x0_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
