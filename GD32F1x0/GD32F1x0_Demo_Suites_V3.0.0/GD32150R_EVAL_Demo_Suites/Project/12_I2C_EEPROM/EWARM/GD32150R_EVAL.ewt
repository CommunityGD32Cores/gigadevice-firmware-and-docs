<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
          </package>
          <package checked="" name="">
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
            <group checked="" name="">
              <check checked="" name=""/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\gd32f1x0_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\systick.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Source\system_gd32f1x0.c</name>
    </file>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>GD32F1x0_EVAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\gd32f150r_eval.c</name>
    </file>
  </group>
  <group>
    <name>GD32F1x0_Peripherals</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_cmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_dbg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_fwdgt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_ivref.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_opa.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_pmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_rcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_slcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_tsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Source\gd32f1x0_wwdgt.c</name>
    </file>
  </group>
  <group>
    <name>Soft_Drive</name>
    <file>
      <name>$PROJ_DIR$\..\Soft_Drive\at24cxx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Soft_Drive\i2c.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Source\IAR\startup_gd32f1x0.s</name>
    </file>
  </group>
</project>


