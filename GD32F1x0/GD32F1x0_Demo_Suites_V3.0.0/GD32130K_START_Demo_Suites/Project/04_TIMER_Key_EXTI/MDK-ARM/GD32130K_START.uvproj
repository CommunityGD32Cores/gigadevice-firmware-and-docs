# Keil uVision project GD32130K_START.uvproj, settings and files
target GD32F130K_START (ARM-ADS)
  device: GD32F130K8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150
  c include: ..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;..\..\..\Utilities;..\..\..\..\GD32F1x0_Firmware_Library\CMSIS;..\..\04_TIMER_Key_EXTI;..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Source\ARM;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32f1x0_it.c systick.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group GD32F1x0_START
    ../../../Utilities/: gd32f130k_start.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Doc
    ../: readme.txt
