# IAR project GD32150C-START.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\..\..\..\GD32F1x0_Firmware_Library\CMSIS; ..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include; ..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_driver\Include; ..\inc; ..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: USE_STDPERIPH_DRIVER; GD32F130_150
  AARM.AUserIncludes: ..\..\..\Library\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\Library\Firmware\GD32F1x0_standard_peripheral\Include; ..\..\..\Library\Firmware\GD32F1x0_usbd_driver\Include; ..\..\..\Library\Utilities; ..\inc
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F150x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: cdc_acm_core.c gd32f1x0_it.c main.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F1x0_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USB_Driver
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
