# Keil uVision project GD32150C-START.uvproj, settings and files
target USBD_CDC_ACM (ARM-ADS)
  device: GD32F150C8 GigaDevice
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USBD_CDC_ACM +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F130_150
  c misc: --c99
  c include: ..\..\..\..\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_usbd_driver\Include;..\..\..\..\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include;..\inc;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Appliction
    ../src/: main.c gd32f1x0_it.c cdc_acm_core.c
  group CMSIS
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F150_Peripherals
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group Startup
    ../../../../GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group USBD_Drivers
    ../../../../GD32F1x0_Firmware_Library/GD32F1x0_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Doc
    ../: readme.txt
