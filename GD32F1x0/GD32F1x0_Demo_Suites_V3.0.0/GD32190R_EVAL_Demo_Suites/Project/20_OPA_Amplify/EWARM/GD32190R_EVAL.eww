<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GD32190R_EVAL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


