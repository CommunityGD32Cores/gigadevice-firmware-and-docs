# IAR project custom_hid.ewp, settings and files
configuration USBD (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\Utilities; ..\inc; ..\..\..\..\Firmware\CMSIS\GD\GD32F1x0\Include; ..\..\..\..\Firmware\GD32F1x0_standard_peripheral\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\class\device\hid\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\device\Include; ..\..\..\..\Firmware\GD32F1x0_usbd_library\usbd\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Custom_HID.srec
  ILINK.IlinkOutputFile: custom_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: custom_hid_itf.c gd32f1x0_it.c gd32f1x0_usbd_hw.c main.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Doc
    ../: readme.txt
  group GD32F1x0_EVAL
    ../../../../Utilities/: gd32f1x0r_eval.c
  group GD32F1x0_StdPeriph
    ../../../../Firmware/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F1x0/Source/IAR/: startup_gd32f1x0.s
  group USBD_Class
    ../../../../Firmware/GD32F1x0_usbd_library/class/device/hid/Source/: custom_hid_core.c
  group USBD_Device
    ../../../../Firmware/GD32F1x0_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../Firmware/GD32F1x0_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
